# Keil uVision project control_board_project.uvprojx, settings and files
target Control_Board (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: control_board +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,USE_STM32100E_EVAL
  c include: .\library\core\inc;.\library\devices\inc;.\src\application\inc;.\src\config\inc;.\src\driver\inc;.\src\usr\inc;D:\software\keil5\ARM\PACK\ARM\CMSIS\5.0.0\CMSIS\Include;.\library\utils;.\library\utils;.\src\usr\inc;.\src\driver\inc;.\src\application\inc;.\src\application\inc;.\library\utils;.\src\application\inc;.\src\driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start_up
    ./start_up/: startup_stm32f10x_md.s
  group core
    ./library/core/src/: system_stm32f10x.c core_cm3.c
  group stm32 library
    ./library/devices/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group driver
    ./src/driver/src/: led.c key.c adc.c stm32f10x_it.c timer.c light.c flash.c flash_test.c
    ./src/config/src/: config_pin.c
    ./library/utils/: delay.c sys.c usart.c
  group app
    ./src/application/src/: command.c app1.c
  group usr
    ./src/usr/src/: main.c
  group config
    ./src/config/inc/: config_pin.h soft_version.h
